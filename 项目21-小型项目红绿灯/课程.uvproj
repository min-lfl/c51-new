# Keil uVision project 课程.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 课程 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Timer0.h Timer0.c delay.h delay.c switch0000.h Switch0000.c int0.c int0.h int1.c int1.h 888led.c 888led.h RGB_LED.c RGB_LED.h
