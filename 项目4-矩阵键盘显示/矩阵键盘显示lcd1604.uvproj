# Keil uVision project 矩阵键盘显示lcd1604.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 矩阵键盘显示lcd1604 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c 888led.c delay.c lcd1602.c 888led.h delay.h lcd1602.h 4x4_16.c 4x4_16.h
