# Keil uVision project projet.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: projet +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c lcd1602.h delay.c delay.h lcd1602.c InterruptTimer0.h Interrupt.c Interrupt.h InterruptTimer0.c HCSR04.c HCSR04.h
